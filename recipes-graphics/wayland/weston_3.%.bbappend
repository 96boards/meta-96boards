FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"

SRC_URI_append_hikey = " file://0001-force-software-cursor.patch \
"
