RDEPENDS_${PN} += "libegl"
