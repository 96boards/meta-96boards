PACKAGECONFIG[egl] = "--enable-egl,--disable-egl,virtual/egl,libegl"
PACKAGECONFIG[gles1] = "--enable-gles1,--disable-gles1,virtual/libgles1,libgles1"
PACKAGECONFIG[gles2] = "--enable-gles2,--disable-gles2,virtual/libgles2,libgles2"
