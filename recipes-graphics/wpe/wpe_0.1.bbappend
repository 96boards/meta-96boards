# these plugins are commercial licensed & remove it from hikey build
RDEPS_EXTRA_remove_hikey-32 = " \
                               gstreamer1.0-plugins-ugly-mpg123 \
                               gstreamer1.0-plugins-bad-hls \
                              "
