# fixes 32bit OPTEE-OS build
OPTEEOUTPUTMACHINE_hikey-32 = "hikey"
