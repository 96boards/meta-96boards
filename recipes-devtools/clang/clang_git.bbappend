EXTRA_OECMAKE_append_class-native = "\
               -DLLVM_TARGETS_TO_BUILD='AArch64;ARM;BPF;Mips;PowerPC;X86' \
"
