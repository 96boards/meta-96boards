FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://0028-bits-siginfo.h-enum-definition-for-TRAP_HWBKPT-is-mi.patch"
